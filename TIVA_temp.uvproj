# Keil uVision project TIVA_temp.uvproj, settings and files
target TIVA Keil C (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Out
  c flags: Optim=3 OneElfS=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c include: C:\ti\TivaWare_C_Series-2.1.2.111
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: main.c startup_rvmdk.S
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.2.111/driverlib/rvmdk/: driverlib.lib
